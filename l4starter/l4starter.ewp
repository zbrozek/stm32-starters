# IAR project l4starter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RE ST STM32L476RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: HSE_VALUE=8000000; STM32L476xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\lib\drivers; ..\lib\stm32l4; ..\lib\stm32l4_hal; ..\lib\freertos_9-0-0\portable\Common; ..\lib\freertos_9-0-0\include; ..\lib\freertos_9-0-0\portable\IAR\ARM_CM4F; ..\lib\freertos_tcp\include; ..\lib\freertos_tcp\portable\Compiler\IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; inc; src; ..\lib\CMSIS-F4-1.5.1\Include; ..\lib\CMSIS-F4-1.5.1\Device\ST\STM32F4xx\Include; ..\lib\freertos-8.2.1\portable\IAR\ARM_CM4F; ..\lib\drivers
  OBJCOPY.OOCOutputFile: l4starter.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c startup_stm32l476xx.s stm32l4xx_it.c
  group drivers
    ../lib/drivers/: pin.c rcc.c spi.c
  group freertos
    ../lib/freertos_9-0-0/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos/portable
    ../lib/freertos_9-0-0/portable/MemMang/: heap_4.c
    ../lib/freertos_9-0-0/portable/IAR/ARM_CM4F/: port.c portasm.s
  group stm32l4_hal
    ../lib/stm32l4_hal/: stm32l4xx_hal.c stm32l4xx_ll_adc.c stm32l4xx_ll_bus.h stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
