# IAR project f4starter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: HSE_VALUE=8000000; STM32F407xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\drivers; ..\lib\stm32f4; ..\lib\stm32f4_hal; ..\lib\freertos_9-0-0\portable\Common; ..\lib\freertos_9-0-0\include; ..\lib\freertos_9-0-0\portable\IAR\ARM_CM4F; ..\lib\freertos_tcp\include; ..\lib\freertos_tcp\portable\Compiler\IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; inc; src; ..\lib\CMSIS-F4-1.5.1\Include; ..\lib\CMSIS-F4-1.5.1\Device\ST\STM32F4xx\Include; ..\lib\freertos-8.2.1\portable\IAR\ARM_CM4F; ..\lib\drivers
  OBJCOPY.OOCOutputFile: f4starter.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c startup_stm32f407xx.s stm32f4xx_it.c system_stm32f4xx.c
  group drivers
    ../drivers/: csp_stm32f4.c ethernet.c pin.c rcc.c spi.c
  group freertos
    ../lib/freertos_9-0-0/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos/portable
    ../lib/freertos_9-0-0/portable/MemMang/: heap_4.c
    ../lib/freertos_9-0-0/portable/IAR/ARM_CM4F/: port.c portasm.s
  group freertos_tcp
    ../lib/freertos_tcp/portable/BufferManagement/: BufferAllocation_2.c
    ../lib/freertos_tcp/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
  group stm32f4_hal_lowlevel
    ../lib/stm32f4_hal/: stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
