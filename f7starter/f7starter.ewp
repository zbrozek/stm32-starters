# IAR project f7starter.ewp, settings and files
configuration STM32F746_Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: HSE_VALUE=25000000; STM32F746xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\drivers; ..\lib\stm32f7; ..\lib\stm32f7_hal; ..\lib\freertos-2022_12_01\portable\Common; ..\lib\freertos-2022_12_01\include; ..\lib\freertos-2022_12_01\portable\IAR\ARM_CM7\r0p1; ..\lib\freertos_plus_tcp-2022_12_01\include; ..\lib\freertos_plus_tcp-2022_12_01\portable\Compiler\IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: f7starter.bin
  ILINK.IlinkOutputFile: f7starter.out
  ILINK.IlinkIcfFile: ..\lib\stm32f7\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F767 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F767NI ST STM32F767NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 7
  ICCARM.CCDefines: HSE_VALUE=8000000; STM32F767xx; CORE_CM7; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\lib\drivers; ..\lib\stm32f7; ..\lib\stm32f7_hal; ..\lib\freertos_9-0-0\portable\Common; ..\lib\freertos_9-0-0\\include; ..\lib\freertos_9-0-0\portable\IAR\ARM_CM7\r0p1; ..\lib\freertos_tcp\include; ..\lib\freertos_tcp\portable\Compiler\IAR
  ILINK.IlinkIcfFile: ..\lib\stm32f7\stm32f767xx_flash.icf
  group (top)
    ./: main.c startup_stm32f767xx.s stm32f7xx_it.c system_stm32f7xx.c
  group drivers
    ../drivers/: csp_stm32f7.c ethernet.c pin.c rcc.c rng.c spi.c
  group freertos
    ../lib/freertos-2022_12_01/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../lib/freertos-2022_12_01/portable/MemMang/: heap_4.c
    ../lib/freertos-2022_12_01/portable/Common/: mpu_wrappers.c
    ../lib/freertos-2022_12_01/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group freertos_plus_tcp
    ../lib/freertos_plus_tcp-2022_12_01/portable/BufferManagement/: BufferAllocation_2.c
    ../lib/freertos_plus_tcp-2022_12_01/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_DNS_Cache.c FreeRTOS_DNS_Callback.c FreeRTOS_DNS_Networking.c FreeRTOS_DNS_Parser.c FreeRTOS_ICMP.c FreeRTOS_IP.c FreeRTOS_IP_Timers.c FreeRTOS_IP_Utils.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_Reception.c FreeRTOS_TCP_State_Handling.c FreeRTOS_TCP_Transmission.c FreeRTOS_TCP_Utils.c FreeRTOS_TCP_WIN.c FreeRTOS_Tiny_TCP.c FreeRTOS_UDP_IP.c
  group stm32f7_hal_lowlevel
    ../lib/stm32f7_hal/: stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_utils.c
